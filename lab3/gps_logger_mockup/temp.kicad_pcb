File: lab3/gps_logger_mockup/temp.kicad_pcb (KiCad board)
At the start: 2 copper layers, 68.6 x 53.3 mm, 158 parts

Commit message: Add mockup shield images
Parts:
- renumbered REF** to ?
